# Keil uVision project BH-F407.uvprojx, settings and files
target SD_CARD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\FATFS;..\..\User\TOUCH_HARDWARE\LED;..\..\User\TOUCH_HARDWARE\LCD;..\..\User\TOUCH_HARDWARE\IIC;..\..\User\TOUCH_HARDWARE\24CXX;..\..\User\TOUCH_HARDWARE\KEY;..\..\User\TOUCH_HARDWARE\TOUCH;..\..\User\USR_CODE;..\..\User\SYSTEM\sys;..\..\User\SYSTEM\delay;..\..\User\SYSTEM\usart;..\..\User\TOUCH_HARDWARE\W25QXX;..\..\User\TOUCH_HARDWARE\SPI;..\..\User\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/sdio/: bsp_sdio_sd.c
    ../../User/USR_CODE/: fonts.c
  group FatFs
    ../../User/FATFS/: diskio.c ff.c
    ../../User/FATFS/option/: cc936.c
  group TOUCH_HARDWARE
    ../../User/TOUCH_HARDWARE/24CXX/: 24cxx.c
    ../../User/TOUCH_HARDWARE/IIC/: myiic.c
    ../../User/TOUCH_HARDWARE/KEY/: key.c
    ../../User/TOUCH_HARDWARE/LCD/: lcd.c
    ../../User/TOUCH_HARDWARE/LED/: led.c
    ../../User/TOUCH_HARDWARE/TOUCH/: touch.c
  group USR_CODE
    ../../User/USR_CODE/: universal_head.h task.c USR_CODE.c gui.c sd_operate.c usr_key.c
  group SYSTEM
    ../../User/SYSTEM/delay/: delay.c
    ../../User/SYSTEM/sys/: sys.c
    ../../User/SYSTEM/usart/: usart.c
  group side
    ../../User/USR_CODE/: gpio.txt
